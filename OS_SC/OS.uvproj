# Keil uVision project OS.uvproj, settings and files
target Target 1 (MCS-51)
  device: 8051 IP Core Oregano Systems
  cpu: IRAM(0-0x7F) XRAM(0-0xFFFF) IROM(0-0xFFF) CLOCK(12000000)
  output: OS +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51
  group New Group
    ./: main.c memory.c hal.c i2c.c command.c response.c transmission.c state.c fs.c krisna.c
